options:
  parameters:
    generate_options: qt_gui
    id: fm_recv_gnuradio_octave
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: buf_size
  id: variable
  parameters:
    value: 32768*2
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    start: '80'
    step: '0.1'
    stop: '120'
    value: '100'
  states: {}
- name: msg_size
  id: variable
  parameters:
    value: '2097152'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: audio_sink_1_0_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/decimation)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: msg_size
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: int(samp_rate/decimation)
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: msg_size
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: buf_size
    filter_source: '''Auto'''
    frequency: int(lo_freq*1e6)
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: int(samp_rate)
    fc: '0'
    fftsize: '1024'
    rate: '15'
    type: float
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '15'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
    vlen: msg_size
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '100'
    type: float
    vlen: msg_size
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_throttle2_0_0_0, '0', audio_sink_1_0_0, '0']
- [blocks_throttle2_0_0_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_throttle2_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_1, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
